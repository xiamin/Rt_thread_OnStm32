# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: src; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; rt-thread\libcpu\arm\stm32; rt-thread\include; rt-thread\components\finsh; rt-thread\components\dfs; rt-thread\components\dfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: .; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\Core\CM3; ..\..\include; ..\..\libcpu\arm\stm32; ..\..\finsh; ..\..\filesystem\dfs; ..\..\filesystem\dfs\include; ..\..\filesystem\dfs\filesystems\efsl\src\include; ..\..\filesystem\dfs\filesystems\efsl\src\base\include; ..\..\filesystem\dfs\filesystems\efsl\src\fs\vfat\include; ..\..\net\lwip\src; ..\..\net\lwip\src\include; ..\..\net\lwip\src\arch\include; ..\..\net\lwip\src\include\ipv4
  ICCARM.CCOptLevel: 3
  group app
    src/: application.c
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group finsh
    rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32
    rt-thread/libcpu/arm/stm32/: context_iar.S cpu.c fault.c fault_iar.S interrupt.c serial.c stack.c start_iar.S
  group system
    src/: board.c startup.c stm32f10x_it.c system_stm32f10x.c usart.c
